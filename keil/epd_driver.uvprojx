# Keil uVision project epd_driver.uvprojx, settings and files
target epd_driver (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: NANO100LE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: epd_driver
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\Library\Device\Nuvoton\Nano100Series\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group USER
    ../USER/: img.h main.cpp UC8581_driver.h
  group LIB
    ../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c uart.c
